# Keil uVision project can_test01.uvprojx, settings and files
target can_test01 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: can_test01 +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o "..\app2_agy.bin" "#L"
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o "..\..\app2_agy.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,USER_VECT_TAB_ADDRESS,VECT_TAB_OFFSET=0x00010000U,LV_CONF_INCLUDE_SIMPLE
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../code;../midware;../midware/lvgl;../midware/lvgl/src;../midware/ui;../midware/ui/images
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c can.c spi.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_spi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group code
    ../code/: headfile.h wrap.h wrap.c lcd.c lcd.h lcd_init.c lcd_init.h lcdfont.h types.h inter_flashif.c inter_flashif.h inter_flash_cfg.c inter_flash_cfg.h bsp_touch.c bsp_touch.h cyber_ui.c cyber_ui.h
  group midware\lvgl\src\core
    ../midware/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group midware\lvgl\src\draw
    ../midware/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_layer.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_transform.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../midware/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c
  group midware\lvgl\src\gpu
    ../midware/lvgl/src/draw/stm32_dma2d/: lv_gpu_stm32_dma2d.c
    ../midware/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_layer.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
  group midware\lvgl\src\extra
    ../midware/lvgl/src/extra/: lv_extra.c
    ../midware/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../midware/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../midware/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../midware/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../midware/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../midware/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_littlefs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../midware/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../midware/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../midware/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../midware/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../midware/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../midware/lvgl/src/extra/libs/tiny_ttf/: lv_tiny_ttf.c
    ../midware/lvgl/src/extra/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../midware/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../midware/lvgl/src/extra/others/ime/: lv_ime_pinyin.c
    ../midware/lvgl/src/extra/others/imgfont/: lv_imgfont.c
    ../midware/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../midware/lvgl/src/extra/others/msg/: lv_msg.c
    ../midware/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../midware/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../midware/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../midware/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../midware/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../midware/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../midware/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../midware/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../midware/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../midware/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../midware/lvgl/src/extra/widgets/led/: lv_led.c
    ../midware/lvgl/src/extra/widgets/list/: lv_list.c
    ../midware/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../midware/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../midware/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../midware/lvgl/src/extra/widgets/span/: lv_span.c
    ../midware/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../midware/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../midware/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../midware/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../midware/lvgl/src/extra/widgets/win/: lv_win.c
  group midware\lvgl\src\font
    ../midware/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group midware\lvgl\src\hal
    ../midware/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group midware\lvgl\src\misc
    ../midware/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group midware\lvgl\src\widgets
    ../midware/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group LVGL/Porting
    ../code/: bsp_lv_port_disp.c bsp_lv_port_indev.c
  group LVGL/BlackCat_UI
    ../code/: blackcat_lvgl_ui.c
    ../midware/ui/images/: ui_img_cat_story_1.c ui_img_cat_story_2.c ui_img_cat_story_3.c ui_img_cat_story_4.c ui_img_cat_story_5.c ui_img_light_png.c ui_img_safety_belt_png.c ui_img_temp_gray_png.c ui_img_turn_light_png.c dashboard_bg_img.c
software components: CMSIS:CORE 4.3.0
